do_configure_append() {
    echo "CONFIG_EFI=y" >> ${B}/.config
}
