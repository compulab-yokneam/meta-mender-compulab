FILESEXTRAPATHS_prepend := "${THISDIR}/compulab/${MACHINE}:"

include compulab/imx8.inc
