u-boot_%.bbappend