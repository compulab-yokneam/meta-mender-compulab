DEBIANNAME_${PN} = "libglib2.0-0"
