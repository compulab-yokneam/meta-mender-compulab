RDEPENDS_${PN}_remove_mender-growfs-data_mender-systemd = "util-linux-fdisk"
RDEPENDS_${PN}_append_mender-growfs-data_mender-systemd = " fdisk "

require mender-data.inc
