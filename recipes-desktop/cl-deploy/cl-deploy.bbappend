FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

CL_DEPLOY_MOD = "1"
