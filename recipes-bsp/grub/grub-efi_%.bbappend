GRUB_BUILDIN:append:mender-grub = " gzio "
RDEPENDS:${PN}:remove  = "u-boot"
