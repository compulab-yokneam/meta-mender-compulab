require u-boot-mender.inc
